# IAR project Secure Comms - Router - AFZDO.ewp, settings and files
configuration Launchpad (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: LAUNCHPAD; ZM_PHY_SPI; REGION_NORTH_AMERICA; DISPLAY_NETWORK_INFORMATION
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZM; ../HAL; ../Common
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_secure_comms_router_afzdo.c module_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_launchpad.c hal_mdb1.c hal_mdb2.c
  group LED
    ../../../../My Documents/backupan/: font.c font.h led_matrix.c led_matrix.h
  group ZM
    ../../ZM/: af.c application_configuration.c module.c module_errors.c module_utilities.c zdo.c zm_phy_spi.c
